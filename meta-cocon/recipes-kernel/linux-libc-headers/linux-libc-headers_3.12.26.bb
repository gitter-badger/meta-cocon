require recipes-kernel/linux-libc-headers/linux-libc-headers.inc


KORG_ARCHIVE_COMPRESSION = "xz"

SRC_URI[md5sum] = "1bb89d56342871b6f310ad9075c51a02"
SRC_URI[sha256sum] = "cce883044f529acde9b1cca85d9210a8fb835dd8be34fb1b7a60f428665ee6be"

