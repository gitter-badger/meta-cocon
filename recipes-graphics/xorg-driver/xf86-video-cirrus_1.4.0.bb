require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- Cirrus display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=6ddc7ca860dc5fd014e7f160ea699295"

SRC_URI[md5sum] = "1e449789da866f974dbf6cbe3c8cc7bf"
SRC_URI[sha256sum] = "2b07fa5d4a86acb277d72c7ae35566ae21b08836645c6a88e7662422af5e962e"
