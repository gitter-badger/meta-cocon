require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- r128 display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=7afbe929192be6cccb50f81b968fd23a"

SRC_URI[md5sum] = "31e0358b5d1189e3f30f5b11e9b86865"
SRC_URI[sha256sum] = "7b41135c3d177e61644573e5c16e35fd9eff98b4d6685c9c6de9e33401e904b1"

