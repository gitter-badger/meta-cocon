EXTRAPATHS_prepend := "${THISDIR}/${PN}:"
