require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- ark display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=bdb6aed1d4651e3c08a43c49b9b286d7"

SRC_URI[md5sum] = "21f5db0beca2d3d99aae739174d5b44f"
SRC_URI[sha256sum] = "bd4cdba48a974acaca289d20b8268a4d3084e2b2c9d1c83adb03ba1dcb609fa4"

