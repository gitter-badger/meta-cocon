require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- S3 ViRGE display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=09743e0f5c076a765cd16697b5b1effb"

SRC_URI[md5sum] = "70956a12113b72e4f6d770e32b2ac4b9"
SRC_URI[sha256sum] = "85e1f6bdd3f39d0348c53602f481b974c13fc752c94931882817751c8ec8363e"
