require recipes-graphics/xorg-driver/xorg-driver-video.inc

PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=0b8c242f0218eea5caa949b7910a774b"

SRC_URI[md5sum] = "3a5ba54cc3f2df366841d54e0d428c79"
SRC_URI[sha256sum] = "17ae87eae437706020b1b1687b9e7a7785f4c61a24973c7e108572d4b35efcc3"

