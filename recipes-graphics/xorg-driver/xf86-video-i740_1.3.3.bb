require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i740 display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=c85da4d100605ac6d8d47d47eb2bf191"

SRC_URI[md5sum] = "6cf0c3c63bb099dbcaa5b901caa554b2"
SRC_URI[sha256sum] = "a39e8cf8e34816d07d33eae79dcb26fc2137f719156ae90fa4afff319e320dcc"

