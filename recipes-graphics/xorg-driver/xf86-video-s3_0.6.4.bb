require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- legacy S3 display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=0eae1e9f9b6904bf113c02c911019b1a"

SRC_URI[md5sum] = "c8d27317de8f38be0548c25634e89350"
SRC_URI[sha256sum] = "1b5f6c4cd02ab13a7d2d0ebb45a7b463650a0187a75e4516a16edb738ce909ff"
