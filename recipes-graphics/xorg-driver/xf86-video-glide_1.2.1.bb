require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- Glide (Voodoo 1 and 2 cards) display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=09743e0f5c076a765cd16697b5b1effb"

SRC_URI[md5sum] = "f7ed58f3bc6b337ac764622a86f4253d"
SRC_URI[sha256sum] = "d74725e0742e8c0d408756eca24a7830f4bc7f529964ee6402fdd1e3db8fe96e"

