require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- i128 display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=47dae2fb2926bd08adffd5128f45190c"

SRC_URI[md5sum] = "392c4ffd3c752af6f92e71e1efd68c66"
SRC_URI[sha256sum] = "3eedeb1e575e96b2ebebdf894c515e8543900aa3f9f85d10120b8240264333ea"

