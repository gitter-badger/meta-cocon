require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- MGA display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=bc1395d2cd32dfc5d6c57d2d8f83d3fc"

SRC_URI[md5sum] = "ff7a9d63978f538a7d5ff5dafe431562"
SRC_URI[sha256sum] = "ca983d780dd90115c0599980a7a83425b5e4eeb16f2e8c7fed15823fcbe7830e"

