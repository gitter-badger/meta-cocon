require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- S3 ViRGE display driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=09743e0f5c076a765cd16697b5b1effb"

SRC_URI[md5sum] = "5b5468c5c58a2e3870567eb7eb935e5e"
SRC_URI[sha256sum] = "583b2d2982c2dd8b3c2d8f09c3cbca901c3cb844115ac99251ae6521560fac31"

