require recipes-graphics/xorg-driver/xorg-driver-video.inc

DESCRIPTION = "X.Org X server -- Basic modesetting driver"
PE = "1"
PR = "${INC_PR}.0"

LIC_FILES_CHKSUM = "file://COPYING;md5=5e53d3fcadb1c23d122ad63cb099a918"

SRC_URI[md5sum] = "5d24106c566d4f7401fc4467a435af68"
SRC_URI[sha256sum] = "0d9e78fa089373350e11dcb88ef7a4d8cfac9234cce2b4ca39a943e80b8a1b95"

